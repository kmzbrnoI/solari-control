# Repository kmzbrnoI/solari-control

File README.md:

Control HW & SW for Solari di Udine platform table
==================================================

This repository contains data to make platform table from company Solari di
Udine work.

1. [PCB](pcb) replacing original PCB with CPU Intel 8080 in the table.
2. [Firmware](fw) to the main MCU of our new PCB (ATmega328p).
3. [SW](sw) to interact with the table.
4. [Web interface](web) to control the table via web browser.
5. [Integration with hJOP](sw) script to show data from the particular train
   on the track on the table.

## Flap units order

0. Train type
1. Train number 0 (left)
2. Train number 1
3. Train number 2
4. Train number 3
5. Train number 4 (right)
6. Final station 0 (left)
7. Final station 1
8. Final station 10
9. Final station 11
10. Final station 12
11. Final station 13 (right)
12. Direction left
13. Direction right
14. Departure hours
15. Departure minutes tenths
16. Final station 2
17. Final station 3
18. Final station 4
19. Final station 5
20. Final station 6
21. Final station 7
22. Final station 8
23. Final station 9
24. Departure minutes ones
25. Delay

## Author

Jan Horáček

## KiCad design pcb/solari-control.kicad_pcb

Parts:
C1, C5, C8, C9, C12, C13, C15, C16, C17: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2: 22u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C3, C6: 22u/25V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C4: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C7: 100n/50V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C10, C11: 22p; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: ESDA6V1-5SC6; SOT-23-6_Handsoldering
D2, D3: 1N4148; D_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D4: GR; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D5: YEL; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D6: RED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
F1, F2, F3, F4: 200mA; Fuse_1206_3216Metric_Pad1.42x1.75mm_HandSolder
H1, H2, H3, H4: MH; MountingHole_3mm_Pad_Via
J1, J6: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
J2: A5081WV-5P; TerminalBlock_bornier-5_P5.08mm
J3: A5081WR-5P; TerminalBlock_bornier-5_P5.08mm
J4: AVR-ISP-6; PinHeader_2x03_P2.54mm_Vertical
J5: DIL8; DIP-16_W7.62mm_LongPads
JP1: Jumper_2_Open; PinHeader_1x02_P2.54mm_Vertical
Q1, Q7, Q8: AO3401A; SOT-23
Q2, Q4: 2N7002; SOT-23
Q3, Q9, Q11: BC857; SOT-23
Q5, Q6: BSS83; SOT-23
Q10, Q12: BC847; SOT-23
R1, R7, R22, R24: 2k2; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2, R14, R19, R26, R27, R28: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3, R4, R9, R16, R18, R21, R29, R31, R34, R36, R38, R40, R43, R44, R46: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R5, R10, R11, R13, R15, R17, R20, R23, R25, R30, R32, R37, R39, R41, R45: 470R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R6, R8, R12, R33, R35: 100R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
TP1, TP2, TP3: TP; TestPoint_Loop_D3.50mm_Drill1.4mm_Beaded
U1, U3, U6, U8, U9: VO0631T; SOIC-8_3.9x4.9mm_P1.27mm
U2: L78L05_SOT89; SOT-89-3_Handsoldering
U4, U5, U10, U11: PC817; DIP-4_W8.89mm_SMDSocket_LongPads
U7: ATmega328P-A; TQFP-32_7x7mm_P0.8mm
U13: ADuM1201AR; SOIC-8_3.9x4.9mm_P1.27mm
Y1: 14.7456 MHz; Crystal_HC49-U_Vertical

Connections:
0PH: C3.2, C4.2, C5.2, D2.2 (A), D3.2 (A), J2.3, J5.9, Q2.2 (S), Q4.2 (E), R9.1, R12.1, R18.1, R21.1, TP3.1, U1.3 (C2), U2.2 (GND), U3.5 (GND), U4.3, U5.3
0V+: C6.2, C7.1, C9.2, C12.2, C13.2, J3.4, Q10.2 (E), Q12.2 (E), R36.2, R38.2, TP2.1, U6.5 (GND), U8.5 (GND), U9.5 (GND), U10.3, U11.3
5VPH: C4.1, C5.1, Q1.2 (S), Q3.2 (E), R4.1, R8.1, U2.1 (OUT), U3.8 (VCC)
/5V: F1.1, J2.1
/CLOCKS: J5.3, Q4.3 (C), R7.1
/CLOCKT: J5.6, R24.1, U6.6 (VO2)
/DATOS: J5.5, R2.2
/DATOT: J5.2, R22.1, U6.7 (VO1)
/GNDU: C17.2, D1.2 (GND), J1.4, U13.5 (GND2)
/ID: J5.15, Q7.3 (D), R36.1
/IP: J5.14, Q8.3 (D), R38.1
/P: D2.1 (K), J5.8, Q5.3 (D), R18.2
/PARSER: J5.4, Q2.3 (D), R3.1
/REL1: J6.2, Q10.3 (C)
/REL2: J6.3, Q12.3 (C)
/RXU: D1.6 (IO5), J1.2, U13.7 (VIA)
/STROBE: J5.1, R29.1, U8.7 (VO1)
/TXU: D1.4 (IO3), J1.3, U13.6 (VOB)
/VCCU: C17.1, J1.1, U13.8 (VDD2)
/Z: D3.1 (K), J5.7, Q6.3 (D), R21.2
/_V+: F3.1, J3.3
/_VDO: F4.1, J3.5
/_VPH: F2.1, J2.4
GND: C1.2, C2.2, C8.2, C10.2, C11.2, C15.2, C16.2, D4.1 (K), D5.1 (K), D6.1 (K), J2.2, J4.6 (GND), TP1.1, U1.5 (GND), U3.2 (C1), U3.3 (C2), U4.2, U5.2, U6.2 (C1), U6.3 (C2), U7.3 (GND), U7.5 (GND), U7.21 (GND), U8.2 (C1), U8.3 (C2), U9.2 (C1), U9.3 (C2), U10.2, U11.2, U13.4 (GND1)
LEDG: R26.1, U7.23 (PC0)
LEDR: R28.1, U7.25 (PC2)
LEDY: R27.1, U7.24 (PC1)
MID: R32.2, U7.26 (PC3)
MIP: R37.2, U7.27 (PC4)
MISO: J4.1 (MISO), R1.1, U1.6 (VO2), U7.16 (PB4)
MOSI: J4.4 (MOSI), R23.2, U7.15 (PB3)
MP: R20.2, U7.2 (PD4)
MPARSER: R5.2, U7.32 (PD2)
MREL1: R41.1, U7.10 (PD6)
MREL2: R45.1, U7.11 (PD7)
MSTROBE: R30.2, U7.9 (PD5)
MZ: R15.2, U7.1 (PD3)
unnamed: C10.1, U7.7 (XTAL1/PB6), Y1.2
unnamed: C11.1, U7.8 (XTAL2/PB7), Y1.1
unnamed: D4.2 (A), R26.2
unnamed: D5.2 (A), R27.2
unnamed: D6.2 (A), R28.2
unnamed: J4.2 (VCC), JP1.2 (B)
unnamed: Q1.1 (G), R4.2, R6.1
unnamed: Q1.3 (D), Q2.1 (G), R9.2
unnamed: Q3.1 (B), R8.2, R10.1
unnamed: Q3.3 (C), R39.2
unnamed: Q4.1 (B), R12.2, R39.1
unnamed: Q5.1 (G), R13.2, R14.1
unnamed: Q6.1 (G), R17.2, R19.1
unnamed: Q7.1 (G), R31.1, R33.1
unnamed: Q8.1 (G), R34.2, R35.1
unnamed: Q9.1 (B), R40.1
unnamed: Q9.3 (C), R43.2
unnamed: Q10.1 (B), R43.1
unnamed: Q11.1 (B), R44.1
unnamed: Q11.3 (C), R46.1
unnamed: Q12.1 (B), R46.2
unnamed: R2.1, U1.4 (A2)
unnamed: R5.1, U3.1 (A1)
unnamed: R6.2, U3.7 (VO1)
unnamed: R10.2, U3.6 (VO2)
unnamed: R11.1, U3.4 (A2)
unnamed: R14.2, U4.4
unnamed: R15.1, U4.1
unnamed: R19.2, U5.4
unnamed: R20.1, U5.1
unnamed: R23.1, U6.1 (A1)
unnamed: R25.1, U6.4 (A2)
unnamed: R30.1, U8.1 (A1)
unnamed: R32.1, U9.1 (A1)
unnamed: R33.2, U9.7 (VO1)
unnamed: R35.2, U9.6 (VO2)
unnamed: R37.1, U9.4 (A2)
unnamed: R40.2, U10.4
unnamed: R41.2, U10.1
unnamed: R44.2, U11.4
unnamed: R45.2, U11.1
RESET: J4.5 (~RST), R16.2, U7.29 (~RESET/PC6)
RX: U7.30 (PD0), U13.2 (VOA)
SCK: J4.3 (SCK), R11.2, R25.2, U7.17 (PB5)
TX: U7.31 (PD1), U13.3 (VIB)
V+: C6.1, C9.1, C12.1, C13.1, F3.2, Q7.2 (S), Q8.2 (S), R22.2, R24.2, R29.2, R31.2, R34.1, U6.8 (VCC), U8.8 (VCC), U9.8 (VCC)
VCC: C1.1, C2.1, C8.1, C15.1, C16.1, F1.2, JP1.1 (A), R1.2, R16.1, U1.8 (VCC), U7.4 (VCC), U7.6 (VCC), U7.18 (AVCC), U13.1 (VDD1)
VDO: C7.2, F4.2, J6.1, Q9.2 (E), Q11.2 (E)
VPH: C3.1, F2.2, J5.16, Q5.2 (S), Q6.2 (S), R3.2, R7.2, R13.1, R17.1, U2.3 (IN)

Notes on the sheet:
To relay board (side switching)
15V
To parent device
Ugs > 30V Uds > 30V
From power supply Flap unit (MR) V+ ~ outputs V+ = 5V VDO = VR = 24-30V
Ugs > 15V Uds > 15V
From power supply Logical (ML) PH ~ inputs VCC = 5V VPH = 15V
Galvanically separated
To flap unit extension card
Alternative: BSS138
Close resistor for fast transitions
S = inputs T = outputs

Board: 2 copper layers, 80.0 x 90.0 mm, 110 parts (81 on the bottom side), 86 nets.

## Code that names these connections

File fw/src/io.h:

#ifndef _IO_H_
#define _IO_H_

/* Basic low-level IO manipulation. */

#include <stdbool.h>

void io_init(void);

inline void io_led_green_on() { PORTC |= (1 << PC0); }
inline void io_led_green_off() { PORTC &= ~(1 << PC0); }
inline void io_led_yellow_on() { PORTC |= (1 << PC1); }
inline void io_led_yellow_off() { PORTC &= ~(1 << PC1); }
inline void io_led_red_on() { PORTC |= (1 << PC2); }
inline void io_led_red_off() { PORTC &= ~(1 << PC2); }

inline bool io_led_green() { return (PORTC >> PC0) & 1; }
inline bool io_led_yellow() { return (PORTC >> PC1) & 1; }
inline bool io_led_red() { return (PORTC >> PC2) & 1; }
inline void io_led_green_toggle() { if (io_led_green()) io_led_green_off(); else io_led_green_on(); }
inline void io_led_yellow_toggle() { if (io_led_yellow()) io_led_yellow_off(); else io_led_yellow_on(); }
inline void io_led_red_toggle() { if (io_led_red()) io_led_red_off(); else io_led_red_on(); }

inline void io_rel1_on() { PORTD |= (1 << PD6); }
inline void io_rel1_off() { PORTD &= ~(1 << PD6); }
inline void io_rel2_on() { PORTD |= (1 << PD7); }
inline void io_rel2_off() { PORTD &= ~(1 << PD7); }

inline void io_z_on() { PORTD |= (1 << PD4); }
inline void io_z_off() { PORTD &= ~(1 << PD4); }
inline void io_p_on() { PORTD |= (1 << PD3); }
inline void io_p_off() { PORTD &= ~(1 << PD3); }
inline void io_parser_on() { PORTD |= (1 << PD2); }
inline void io_parser_off() { PORTD &= ~(1 << PD2); }
inline void io_strobe_on() { PORTD |= (1 << PD5); }
inline void io_strobe_off() { PORTD &= ~(1 << PD5); }
inline void io_id_on() { PORTC |= (1 << PC3); }
inline void io_id_off() { PORTC &= ~(1 << PC3); }
inline void io_ip_on() { PORTC |= (1 << PC4); }
inline void io_ip_off() { PORTC &= ~(1 << PC4); }

#endif

## Commit log

2023-05-06 Add KiCad .gitignore.
2023-05-06 Add empty KiCad project.
2023-05-06 Add almost-empty readme.
2023-05-07 Sch: add MCU, prog. conn., UART connector.
2023-05-07 Sch: connect expander connector.
2023-05-07 Add relay connection.
2023-05-07 Add ID & IP outputs.
2023-05-07 Use proper capacitors.
2023-05-07 Add RX & TX markers.
2023-05-23 Add voltage levels (measured).
2023-05-28 Add fuses on power input.
2023-05-28 Add transistors for 15V outputs.
2023-06-04 Add footprints.
2023-06-04 Fix transistors on outputs.
2023-06-04 PCB: place parts into chunks.
2023-06-06 Use 3V3 power supply.
2023-06-06 Add power jumper for AVR-ISP connector.
2023-06-06 ATmega328p: connecrt also AVCC (required by ICSP).
2023-06-15 PCB: partially wire galvanic separation on IO.
2023-06-17 Wire whole PCB.
2023-06-17 Silkscreen fixes.
2023-06-17 Add test points for remaining grounds.
2023-06-17 Sch: use galvanic separation on UART interface.
2023-06-17 Sch: power logic from 5V.
2023-06-17 Wire new changes on PCB.
2023-06-17 Add Makefile for running KiKit.
2023-06-17 Fix DRC warnings.
2023-06-24 Move pcb to separate directory.
2023-06-24 Add firmware template.
2023-06-25 Remove unused sources from Makefile.
2023-07-03 Add LEDs control.
2023-07-03 Add proper fuses.
2023-07-03 Fix external oscillator freqency.
2023-07-04 Add GPIO for all hardware.
2023-07-05 Add UART support.
2023-07-05 Add support for flap units (not tested yet).
2023-07-05 Use bipolar resistors for relay control.
    Ugs must be >= 30 V, this is unachivable with MOSFETs in SOT23.
2023-07-05 Use lower pullups on DATOT & CLOCKT for faster edges.
2023-07-05 Activate relay1 after start (one side active).
2023-07-05 Fix CLK polarity.
    Polarity is inverted in hardware.
2023-07-05 SPI: fix MOSI polarity.
    Polarity is inverted in hardware.
2023-07-06 PCB: tweak fast signal resistors, use bipolar transistors for fast signals.
2023-07-06 SPI: read by default.
2023-07-06 Fix 'Z' & 'P' pins.
2023-07-06 Add first version of control script.
2023-07-06 Yellow LED indicates received data, green liveness.
2023-07-06 control.py: fix sending data.
2023-07-06 Add __pycache__ to .gitignore.
2023-07-06 Add rest of alphabet, flake8.
2023-07-06 control.py: prepare for other flaps.
2023-07-06 Place new resistor on PCB.
2023-07-06 Fix sensors data showing.
2023-07-07 Invert recieved data.
2023-07-07 Fix flap unit reading (order).
2023-07-08 Tweak flapping period.
2023-07-08 Initialize flap units after startup time.
    This is needed for proper first data load.
2023-07-08 Fix parsing of FLAP_SINGLE_CLAP UART message.
2023-07-08 Use 24 flap units.
2023-07-08 Add get target messages.
2023-07-08 Make flap unit work.
2023-07-08 Add proper flap units order.
2023-07-08 control.py: add table strings.
2023-07-08 control.py without arguments resets table.
2023-07-08 Update pull-up resistor value.
2023-07-08 Red LED indicates flap.
2023-07-08 Send sensors & position after each flap or timeout.
2023-07-08 26 flap units.
2023-07-08 control.py: exit after reaching desired position.
2023-07-09 control.py: allow red train number.
2023-07-09 Make UART_MSG_MS_FLAP work.
2023-07-09 control.py: use docopt, use logging.
2023-07-09 control.py: add 'Flap' program.
2023-07-09 control.py: add loop subprogram.
2023-07-09 set_positions: add wait mode.
2023-07-09 Fix SPI polarity.
    Polarity is different on read & write.
2023-07-09 Fix overflow detection.
2023-07-09 control.py: add time & delay.
2023-07-09 Fix train number.
2023-07-10 avr: implement both sides.
2023-07-11 Make parsing of side work.
2023-07-11 Make both sides work.
2023-10-05 Move control.py to 'sw'.
2023-10-05 control.py: allow reading dict from stdin.
2023-10-05 Fix side.
2023-10-05 Add web template.
2023-10-06 Web: add all inputs.
2023-10-06 Add index.php.
2023-10-06 Make web work.
2023-10-08 control.py: log to stdout.
2023-10-08 web: several GUI enhancements.
2023-10-08 Web: avoid warnings.
2023-10-09 Add setup.cfg for flake8.
2023-10-09 control.py: make it flake8-compliant.
2023-10-09 Check letters availability via assert.
2023-10-09 Add missing '-' to FLAP_ALPHABET.
2023-11-20 web: remove duplicities.
2023-12-18 Add hJOP autoset.
2023-12-21 hJOP: add both sides, flake8.
2024-01-18 Add enable block.
2024-01-18 Do not show leading zero in train number.
2024-01-21 Add 'state' command to read table state.
2024-01-22 Make 'state' work.
2024-01-25 Better parsing, pass side to receive functions.
2024-01-25 Log debug print when side mismatch.
2024-01-25 Web: use sans-serif font.
2024-01-25 Fill README.
2024-01-31 Minor enhancements based on edulint output.
2024-01-31 Check for flap units errors.
    Do not flap errorneous units infinitely.
    Change side even if some unit is not in target position.
    Solution: count flaps since increment input change & since reset input.
    If the the value exceeds predefined limit, mark flap unit as failed
    and do not consider it in target_reached.
2024-02-08 Sch: add programming strength note.
2024-02-12 control.py: read: indicate table with fault.
2024-02-12 hJOP: add systemd service file.
2024-03-11 Do not fail when longer 'final' received.
2024-04-14 Init upload
2024-04-14 Init commit
2024-04-14 File duplication error
2024-04-14 Files missing problem fix
2024-04-16 Resolution fix
2024-04-21 v 1.1
2024-04-25 Reload fix
2024-05-06 Web UI small fixes - 1st part
2024-05-06 Web UI small fixes - 2nd part
2024-05-09 Avoid favicon loading.
2024-05-11 FontAwesome added
